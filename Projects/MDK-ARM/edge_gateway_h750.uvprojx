# Keil uVision project edge_gateway_h750.uvprojx, settings and files
target gateway_h750 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32H750XBHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00020000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: edge_gateway_h750 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H750xx,LV_CONF_INCLUDE_SIMPLE
  c include: ..\..\Drivers;..\..\Drivers\CMSIS\Include;..\..\Drivers\CMSIS\Device\ST\STM32H7xx\Include;..\..\Drivers\STM32H7xx_HAL_Driver\Inc;..\..\Middlewares;..\..\User;..\..\App;..\..\Port;..\..\config;..\..\Middlewares\FreeRTOS\include;..\..\Middlewares\FreeRTOS\portable\RVDS\ARM_CM4F;..\..\Middlewares\LVGL;..\..\Middlewares\LVGL\src
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: ..\..\User\SCRIPT\qspi_code.scf
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h750xx.s
  group User
    ../../User/: main.c stm32h7xx_it.c
    ../../Drivers/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/usart/: usart.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_gpio.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_sdram.c stm32h7xx_ll_fmc.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_iwdg.c
  group Drivers/BSP
    ../../Drivers/BSP/LED/: led.c
    ../../Drivers/BSP/KEY/: key.c
    ../../Drivers/BSP/MPU/: mpu.c
    ../../Drivers/BSP/LCD/: lcd.c ltdc.c
    ../../Drivers/BSP/SDRAM/: sdram.c
    ../../Drivers/BSP/IIC/: myiic.c
    ../../Drivers/BSP/24CXX/: 24cxx.c
    ../../Drivers/BSP/TOUCH/: ctiic.c ft5206.c gt9xxx.c touch.c
  group Readme
    ../../: readme.txt
  group Gateway
    ../../App/: font_chinese_9.c gateway_at.c gateway_network.c gateway_protocol.c gateway_store.c gateway_tasks.c gateway_ui.c
  group Gateway/Port
    ../../Port/: gateway_board.c lv_port_h750.c
    ../../Drivers/BSP/SPI/: spi.c
    ../../Drivers/BSP/PCF8574/: pcf8574.c
  group FreeRTOS
    ../../Middlewares/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../Middlewares/FreeRTOS/portable/MemMang/: heap_4.c
    ../../Middlewares/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group LVGL
    ../../Middlewares/LVGL/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../../Middlewares/LVGL/src/draw/arm2d/: lv_gpu_arm2d.c
    ../../Middlewares/LVGL/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../../Middlewares/LVGL/src/draw/nxp/pxp/: lv_draw_pxp.c lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    ../../Middlewares/LVGL/src/draw/nxp/vglite/: lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_line.c lv_draw_vglite_rect.c lv_vglite_buf.c lv_vglite_utils.c
    ../../Middlewares/LVGL/src/draw/renesas/: lv_gpu_d2_draw_label.c lv_gpu_d2_ra6m3.c
    ../../Middlewares/LVGL/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../../Middlewares/LVGL/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../../Middlewares/LVGL/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../../Middlewares/LVGL/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    ../../Middlewares/LVGL/src/extra/layouts/flex/: lv_flex.c
    ../../Middlewares/LVGL/src/extra/layouts/grid/: lv_grid.c
    ../../Middlewares/LVGL/src/extra/libs/bmp/: lv_bmp.c
    ../../Middlewares/LVGL/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../../Middlewares/LVGL/src/extra/libs/freetype/: lv_freetype.c
    ../../Middlewares/LVGL/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../../Middlewares/LVGL/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../../Middlewares/LVGL/src/extra/libs/png/: lodepng.c lv_png.c
    ../../Middlewares/LVGL/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../../Middlewares/LVGL/src/extra/libs/rlottie/: lv_rlottie.c
    ../../Middlewares/LVGL/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../../Middlewares/LVGL/src/extra/libs/tiny_ttf/: lv_tiny_ttf.c
    ../../Middlewares/LVGL/src/extra/: lv_extra.c
    ../../Middlewares/LVGL/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../../Middlewares/LVGL/src/extra/others/gridnav/: lv_gridnav.c
    ../../Middlewares/LVGL/src/extra/others/ime/: lv_ime_pinyin.c
    ../../Middlewares/LVGL/src/extra/others/imgfont/: lv_imgfont.c
    ../../Middlewares/LVGL/src/extra/others/monkey/: lv_monkey.c
    ../../Middlewares/LVGL/src/extra/others/msg/: lv_msg.c
    ../../Middlewares/LVGL/src/extra/others/snapshot/: lv_snapshot.c
    ../../Middlewares/LVGL/src/extra/themes/basic/: lv_theme_basic.c
    ../../Middlewares/LVGL/src/extra/themes/default/: lv_theme_default.c
    ../../Middlewares/LVGL/src/extra/themes/mono/: lv_theme_mono.c
    ../../Middlewares/LVGL/src/extra/widgets/animimg/: lv_animimg.c
    ../../Middlewares/LVGL/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../../Middlewares/LVGL/src/extra/widgets/chart/: lv_chart.c
    ../../Middlewares/LVGL/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../../Middlewares/LVGL/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../../Middlewares/LVGL/src/extra/widgets/keyboard/: lv_keyboard.c
    ../../Middlewares/LVGL/src/extra/widgets/led/: lv_led.c
    ../../Middlewares/LVGL/src/extra/widgets/list/: lv_list.c
    ../../Middlewares/LVGL/src/extra/widgets/menu/: lv_menu.c
    ../../Middlewares/LVGL/src/extra/widgets/meter/: lv_meter.c
    ../../Middlewares/LVGL/src/extra/widgets/msgbox/: lv_msgbox.c
    ../../Middlewares/LVGL/src/extra/widgets/span/: lv_span.c
    ../../Middlewares/LVGL/src/extra/widgets/spinbox/: lv_spinbox.c
    ../../Middlewares/LVGL/src/extra/widgets/spinner/: lv_spinner.c
    ../../Middlewares/LVGL/src/extra/widgets/tabview/: lv_tabview.c
    ../../Middlewares/LVGL/src/extra/widgets/tileview/: lv_tileview.c
    ../../Middlewares/LVGL/src/extra/widgets/win/: lv_win.c
    ../../Middlewares/LVGL/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
    ../../Middlewares/LVGL/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../../Middlewares/LVGL/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../../Middlewares/LVGL/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
